# IAR project device_driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..\source\framework; ..\..\source\driver_demos
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: device_driver.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.cpp
  group driver_demos
    ../../source/driver_demos/: demo_iic_bus01.c demo_iic_bus01.h demo_iic_eeprom_at24c01.c demo_iic_eeprom_at24c01.h demo_spi_bus01.c demo_spi_bus01.h demo_uart_debug.c demo_uart_debug.h
  group framework/core
    ../../source/framework/core/: device.h device_bus.h device_driver_manager.c device_driver_manager.h device_macro.h device_state.h device_type.h error_code.h types.h
  group framework/interface
    ../../source/framework/interface/: device_driver_adc.h device_driver_can.h device_driver_eeprom.h device_driver_ext_irq.h device_driver_gpio.h device_driver_iic.h device_driver_spi.h device_driver_timer.h device_driver_uart.h device_driver_usb.h interface.h
  group framework/interface/lock
    ../../source/framework/interface/lock/: mutex.h
  group framework/platform
    ../../source/framework/platform/: platform.c platform.h platform_mutex.c platform_mutex.h
  group framework/utils
    ../../source/framework/utils/: list_head.h
